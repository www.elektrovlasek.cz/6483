Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-09-01T08:59:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 01 08:59:06 2020 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{A40ADD91-F881-4F25-8765-7D3FE4602BAA}\ifc * Database version: 5507 * Database creation date: Tue Sep 01 08:59:05 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 01 08:59:06 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 01 08:59:06 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 21543056_OE1_11479860_G5430SCi_BW, 11479860_OE1_G5430SCi_BW:21543056_OE1_11479860_G5430SCi_BW:208210
In: Level 1
Type - Material: z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_Glass Black, z_Miele_Design_BRWS, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - Reference: 21543056_OE1_11479860_G5430SCi_BW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
